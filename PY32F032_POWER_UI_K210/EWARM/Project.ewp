# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F032x8 Puya PY32F032x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F032x8
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\PY32F032xx_Start_Kit; ..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F032\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\PY32F032_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: PY32F032x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/PY32F032xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F032xx_Start_Kit/: py32f032xx_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32f032.c
  group Drivers/PY32F032_HAL_Driver
    ../../../../../../Drivers/PY32F032_HAL_Driver/Src/: py32f032_hal.c py32f032_hal_cortex.c py32f032_hal_rcc.c py32f032_hal_rcc_ex.c py32f032_hal_pwr.c py32f032_hal_pwr_ex.c py32f032_hal_gpio.c py32f032_hal_dma.c py32f032_hal_uart.c
  group Example/EWARM
    ./: startup_py32f032xx.s
  group Example/User
    ../Src/: main.c py32f032_hal_msp.c py32f032_it.c
